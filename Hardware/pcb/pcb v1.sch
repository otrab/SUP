File: Hardware/pcb/pcb v1.sch (EAGLE design)
At the start: 0 parts

Commit message: Añadir partes y gitignore
Parts:
- added Y1: CFS206, partes:CFS206
